require dmtcp.inc

SRCREV = "39c7e1c2f869df9b62897d6ef5cc948b2382d304"
 